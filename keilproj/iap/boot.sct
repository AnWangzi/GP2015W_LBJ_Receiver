LR_BOOT 0x00000000 0x00002000 {
  ER_BOOT 0x00000000 0x00002000 {
    *(RESET, +First)
    *(InRoot$$Sections)
    .ANY (+RO)
  }
  RW_BOOT 0x20000000 0x00003FF0 { .ANY (+RW +ZI) }
}
