# Keil uVision project 1.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: HC32L176KATA HDSC
  pack: HDSC.HC32L17x.1.2.0
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: lcdtest
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: HC32L176
  c include: .\src;.\common\ddl\inc;.\common\ddl\common;.\common\cmsis
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: .\flash.sct
  group src
    ./src/: main.c lcd_8080.c lcd_buffer.c lcd_text.c font_data.c si446x.c radio_config.c radio_task.c pocsag.c lbj_parse.c lbj_state.c train_class.c history.c power_sleep.c buttons.c board_io.c app_ui.c app_view.c iap_entry.c battery.c battery_model.c battery_icon.c
  group device
    ./common/device/: startup_hc32l17x.s system_hc32l17x.c
  group ddl
    ./common/ddl/src/: ddl.c gpio.c sysctrl.c
